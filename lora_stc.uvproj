# Keil uVision project lora_stc.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: lora_stc
  c flags: Optimize=8 SizeSpeed=1
  c include: .\inc
  group Source Group 1
    ./: STARTUP.A51
    ./Source/: eeprom.c main.c spi.c uart.c
  group Inc
    ./inc/: spi.h STC12C5A60S2.H type.h uart.h
